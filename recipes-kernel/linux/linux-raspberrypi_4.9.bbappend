CMDLINE_prepend = "logo.nologo fbcon=map:10 splash plymouth.ignore-serial-consoles "
